PACKAGECONFIG_append = " accessibility fontconfig sql-sqlite kms"
PACKAGECONFIG_remove = "examples tests"
